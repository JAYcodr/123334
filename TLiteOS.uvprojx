# Keil uVision project TLiteOS.uvprojx, settings and files
target TLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TLiteOS +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\OS_CONFIG;..\Middlewares\arch\arm\arm-m\include;..\Middlewares\kernel\include;..\Middlewares\kernel\base\include;..\Middlewares\kernel\extended\include;.\src\include;.\src\VL53L0X\Include;.\src\OLED\OLED_Include;.\src;.\src\HC08
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ./src/C/: binky_demo.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_ll_usart.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middleware/LiteOS/arch
    ../Middlewares/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
    ../Middlewares/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group Middleware/LiteOS/kernel
    ../Middlewares/kernel/: los_init.c
    ../Middlewares/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Middlewares/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Middlewares/kernel/base/mem/common/: los_slab.c los_slabmem.c los_memcheck.c los_memstat.c
    ../Middlewares/kernel/base/misc/: los_misc.c
    ../Middlewares/kernel/base/om/: los_err.c
    ../Middlewares/kernel/extended/tickless/: los_tickless.c
    ../Middlewares/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../Middlewares/kernel/base/mem/membox/: los_membox.c
  group SYSTEM
    ./src/VL53L0X/: delay.c sys.c key.c led.c
    ../Src/: Queue.c Uart_msp.c Debug.c
    ./src/C/: 24cxx.c adc.c IIC_msp.c tim.c
  group Driver/vl53l0x
    ./src/VL53L0X/: vl53l0x.c vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_gen.c vl53l0x_i2c.c vl53l0x_platform.c
  group Driver/OLED
    ./src/OLED/: oled.c font.c OLED_IIC.c
  group Driver/HC08
    ./src/HC08/: hc05.c timer.c usart3.c
software components: CMSIS:CORE 4.3.0
